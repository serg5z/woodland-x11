/* host/viewer_scroll.c: AppKit scroll deltas to X11 wheel clicks. */
#include <stdio.h>

#include "../host/viewer_scroll.h"

static int failures;
#define CHECK(c) do { if (!(c)) { fprintf(stderr, "%s:%d: CHECK failed: %s\n", __FILE__, __LINE__, #c); ++failures; } } while (0)

static int sum(viewer_scroll *s, int n, double dy, int precise, int *events_with_clicks) {
  int total = 0, ev = 0;
  for (int i = 0; i < n; ++i) {
    int c = viewer_scroll_event(s, dy, 0, precise, 0, 0);
    total += c;
    ev += c != 0;
  }
  if (events_with_clicks) *events_with_clicks = ev;
  return total;
}

int main(void) {
  viewer_scroll s;
  int ev, cx;
  /* a short trackpad swipe: 40 events of 3 points = 120 points = 5 clicks (was 40) */
  viewer_scroll_reset(&s);
  CHECK(sum(&s, 40, 3, 1, &ev) == 5 && ev == 5);
  /* small deltas: nothing until a whole click, the remainder kept */
  viewer_scroll_reset(&s);
  CHECK(viewer_scroll_event(&s, 10, 0, 1, 0, 0) == 0);
  CHECK(viewer_scroll_event(&s, 10, 0, 1, 0, 0) == 0);
  CHECK(viewer_scroll_event(&s, 10, 0, 1, 0, 0) == 1);   /* 30 points */
  CHECK(viewer_scroll_event(&s, 18, 0, 1, 0, 0) == 1);   /* 6 left + 18 */
  /* down: negative */
  viewer_scroll_reset(&s);
  CHECK(sum(&s, 8, -6, 1, 0) == -2);
  /* a large fling event: bounded, no stored excess */
  viewer_scroll_reset(&s);
  CHECK(viewer_scroll_event(&s, 2400, 0, 1, 0, 0) == 4);
  CHECK(viewer_scroll_event(&s, 1, 0, 1, 0, 0) == 0);    /* nothing left over (not 96 clicks) */
  /* alternating directions: the remainder is dropped on reversal, no drift */
  viewer_scroll_reset(&s);
  CHECK(viewer_scroll_event(&s, 20, 0, 1, 0, 0) == 0);
  CHECK(viewer_scroll_event(&s, -20, 0, 1, 0, 0) == 0);  /* not 20 - 20 = 0 then a click later */
  CHECK(viewer_scroll_event(&s, -20, 0, 1, 0, 0) == -1);
  int total = 0;
  for (int i = 0; i < 100; ++i) total += viewer_scroll_event(&s, i & 1 ? -23 : 23, 0, 1, 0, 0);
  CHECK(total == 0);
  /* an ordinary wheel: one notch is one click, at once; accelerated notches several, bounded */
  viewer_scroll_reset(&s);
  CHECK(viewer_scroll_event(&s, 1, 0, 0, 0, 0) == 1);
  CHECK(viewer_scroll_event(&s, -1, 0, 0, 0, 0) == -1);
  CHECK(viewer_scroll_event(&s, 3, 0, 0, 0, 0) == 3);
  CHECK(viewer_scroll_event(&s, 25, 0, 0, 0, 0) == 4);
  CHECK(viewer_scroll_event(&s, 0.4, 0, 0, 0, 0) == 0);  /* the excess of the bounded event is gone */
  /* a new gesture or a reset drops the remainder */
  viewer_scroll_reset(&s);
  CHECK(viewer_scroll_event(&s, 20, 0, 1, 0, 0) == 0);
  CHECK(viewer_scroll_event(&s, 20, 0, 1, 1, 0) == 0);   /* began: 20, not 40 */
  viewer_scroll_reset(&s);
  CHECK(s.x == 0 && s.y == 0);
  /* horizontal, accumulated the same way */
  viewer_scroll_reset(&s);
  CHECK(viewer_scroll_event(&s, 0, 50, 1, 0, &cx) == 0 && cx == 2);
  CHECK(viewer_scroll_event(&s, 0, -30, 1, 0, &cx) == 0 && cx == -1);
  /* events generated by a long swipe with momentum: 200 events of 2..12 points */
  viewer_scroll_reset(&s);
  total = 0;
  int clicks_events = 0;
  for (int i = 0; i < 200; ++i) {
    int c = viewer_scroll_event(&s, 2 + (i % 11), 0, 1, 0, 0);
    total += c;
    clicks_events += c != 0;
  }
  CHECK(total == 1391 / 24);   /* sum of the deltas: 18 * (22 + 55) + 2 + 3 = 1391 points: 57 clicks */
  CHECK(clicks_events == total);  /* small events: never more than one click each */
  if (failures) {
    fprintf(stderr, "%d failure(s)\n", failures);
    return 1;
  }
  puts("viewer scroll tests OK");
  return 0;
}
